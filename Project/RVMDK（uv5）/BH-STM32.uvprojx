# Keil uVision project BH-STM32.uvprojx, settings and files
target NKP-540_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NKP-540_APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,__STRICT_ANSI__
  c include: ..\..\App_Common;..\..\App_Modbus;..\..\Drv_Common;..\..\Drv_Modbus;..\..\Arm;..\..\Libraries;..\..\Libraries\FWlib\inc;..\..\Mid_Modbus;..\..\Mid_Modbus\rtu;..\..\Mid_Modbus\include;..\..\Rtt_Segger;..\..\Drv_Sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App_Common
    ../../App_Common/: main.c sensor_app.c analogout_app.c hmi_app.c store_app.c
  group App_Modbus
    ../../App_Modbus/: modbus_app.c
  group Mid_Modbus
    ../../Mid_Modbus/: mb.c modbus_slave.c
    ../../Mid_Modbus/functions/: mbfuncdisc.c mbfuncholding.c mbutils.c
    ../../Mid_Modbus/rtu/: mbcrc.c mbrtu.c
  group Drv_Sensor
    ../../Drv_Sensor/: sensor_drv.c energy_meter_drv.c
  group Drv_Common
    ../../Drv_Common/: stm32f10x_it.c systick_drv.c delay.c led_drv.c eeprom_drv.c key_drv.c iap_drv.c lcd12864_drv.c switch_drv.c iwdg_drv.c gp8202as_drv.c signal_drv.c usb2Com_drv.c ht7036_drv.c max7219_drv.c timing_drv.c
  group Drv_Modbus
    ../../Drv_Modbus/: portevent.c portserial.c porttimer.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Arm
    ../../Arm/: system_stm32f10x.c startup_stm32f10x_hd.s
  group Doc
    ../../Doc/: readme.txt
  group RTT_Segger
    ../../Rtt_Segger/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: Compiler:I/O:STDERR 1.2.0
